Commit message: change urdf

File: araknoBot/resources/urdfs/arakno.urdf (robot description, URDF)
Before this commit: robot arakno, 13 links, 12 joints
Links:
- link trunk: mass 10.0 -> 25.0
